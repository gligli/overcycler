# Repository gligli/overcycler

File README.md:

overcycler
==========

Affordable DIY polyphonic (6 voices) hybrid single cycle / analog synthesizer

Everything is under GPL v3 license, except files that have their own license in the header.

More details on my synth blog: http://gliglisynth.blogspot.com/search/label/overcycler

## KiCad design enclosure/WH148/WH148.kicad_pcb

Parts:
J1, J2: Conn_01x07; JST_PH_B7B-PH-K_1x07_P2.00mm_Vertical
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10: 5K; WH148

Connections:
+3.3V: J1.2, J2.2, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3
GND: J1.1, J2.1, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1
unnamed: J1.3, RV1.2
unnamed: J1.4, RV2.2
unnamed: J1.5, RV3.2
unnamed: J1.6, RV4.2
unnamed: J1.7, RV5.2
unnamed: J2.3, RV6.2
unnamed: J2.4, RV7.2
unnamed: J2.5, RV8.2
unnamed: J2.6, RV9.2
unnamed: J2.7, RV10.2

Board: 2 copper layers, 132.1 x 55.5 mm, 12 parts (12 on the bottom side), 12 nets.

## KiCad design hardware/overcycler3.kicad_pcb

Board: 2 copper layers, 233.7 x 168.2 mm, 327 parts (0 on the bottom side), 271 nets.

Parts:
C1, C9: 22p; C_0805_2012Metric
C2, C3, C4, C5, C6, C7: 10nF; C_0805_2012Metric
C8, C35, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C112, C113, C114: 100n; C_0805_2012Metric
C10, C11, C12, C14, C15, C16, C17, C18, C19, C22, C23, C24, C25, C26, C27, C28, C30, C31, C32, C34, C115, C116, C117, C118, C119, C120, C121, C122, C123, C124, C125: 100nF; C_0805_2012Metric
C13: 470uF; CP_EIA-7343-43_Kemet-X
C20, C21, C29: 10uF; CP_EIA-3216-18_Kemet-A
C33, C36, C48, C61, C71, C81, C91, C101, C111: 100u; CP_EIA-3528-21_Kemet-B
C49: 10u; CP_EIA-3216-18_Kemet-A
C50, C51: 100p; C_0805_2012Metric
C52, C53, C62, C63, C72, C73, C82, C83, C92, C93, C102, C103: 22u; C_0805_2012Metric
C54, C60, C64, C70, C74, C80, C84, C90, C94, C100, C104, C110: 470n; C_0805_2012Metric
C55, C56, C57, C65, C66, C67, C75, C76, C77, C85, C86, C87, C95, C96, C97, C105, C106, C107: 10n; C_0603_1608Metric
C58, C68, C78, C88, C98, C108: 820p; C_0603_1608Metric
C59, C69, C79, C89, C99, C109: 47u; C_1206_3216Metric
D1, D2, D3, D4, D5: 1N4148; D_SOD-123
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4mm_Pad
IC1, IC2, IC3: LM13700; SO-16_3.9x9.9mm_P1.27mm
J1: USB_B; USB_B_Lumberg_2411_02_Horizontal
J2, J4, J5: AudioJack3_Switch; Jack_6.35mm_Neutrik_NMJ6HFD2_Horizontal
J3: DIN-5_180degree; DIN-5-180
J6: Control_Up; JST_PH_B7B-PH-K_1x07_P2.00mm_Vertical
J7: Keyboard; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J8: Display; IDC-Header_2x08_P2.54mm_Vertical
J9: FT232; PinSocket_1x06_P2.54mm_Vertical
J10: Control_Down; JST_PH_B7B-PH-K_1x07_P2.00mm_Vertical
L1: 10u; L_0805_2012Metric
OC1: 6N139; DIP-8_W7.62mm
PS1: IA0505S-2W
PS2: IB0503LSY-1WR1; IB0503LSY
Q1: 2SC945; SOT-23
R1, R6, R11, R37, R40: 1k; R_0805_2012Metric
R2, R4: 33; R_0805_2012Metric
R3, R7, R12, R13, R14, R17, R41, R42, R43, R44, R59, R76, R93, R110, R127, R144, R151: 10k; R_0805_2012Metric
R5: 1k5; R_0805_2012Metric
R8: 220k; R_0805_2012Metric
R9: 1M; R_0805_2012Metric
R10, R49, R50, R51, R53, R54, R57, R66, R67, R68, R70, R71, R74, R83, R84, R85, R87, R88, R91, R100, R101, R102, R104, R105, R108, R117, R118, R119, R121, R122, R125, R134, R135, R136, R138, R139, R142: 15k; R_0805_2012Metric
R15, R24: 100k; R_0805_2012Metric
R16, R22, R23, R58, R62, R65, R75, R79, R82, R92, R96, R99, R109, R113, R116, R126, R130, R133, R143, R147, R150: 4k7; R_0805_2012Metric
R18, R20, R25, R60, R61, R77, R78, R94, R95, R111, R112, R128, R129, R145, R146: 470; R_0805_2012Metric
R19: 3M3; R_0805_2012Metric
R21: 270; R_0805_2012Metric
R26: 220; R_0805_2012Metric
R27, R36: 33k; R_0805_2012Metric
R28, R35, R45, R46: 47k; R_0805_2012Metric
R29, R34: 120k; R_0805_2012Metric
R30, R33: 56k; R_0805_2012Metric
R31, R32: 82k; R_0805_2012Metric
R38, R39: 2k2; R_0805_2012Metric
R47, R48: 330; R_0805_2012Metric
R52, R69, R86, R103, R120, R137: 6k8; R_0805_2012Metric
R55, R72, R89, R106, R123, R140: 390; R_0805_2012Metric
R56, R63, R73, R80, R90, R97, R107, R114, R124, R131, R141, R148: 820; R_0805_2012Metric
R64, R81, R98, R115, R132, R149: 22k; R_0805_2012Metric
R152: 2k7; R_0805_2012Metric
RV1: 10k; Potentiometer_Alps_RK163_Dual_Horizontal
SW1: RESET; SW_PUSH_6mm
SW2: POWER; SPUN192600
U1: W25Q512JVFIQ; SOIC-16W_7.5x10.3mm_P1.27mm
U2, U6: TL064; SO-14_3.9x8.65mm_P1.27mm
U3: LPC1778FBD144; LQFP-144_20x20mm_P0.5mm
U4: TLV2556; SOIC-20W_7.5x12.8mm_P1.27mm
U5: 74HC138; SO-16_3.9x9.9mm_P1.27mm
U7: AD5674R; LFCSP-28-1EP_4x4mm_P0.4mm_EP2.6x2.6mm_ThermalVias
U8, U10, U12, U14, U16, U18: MCP4922-ESL; SO-14_3.9x8.65mm_P1.27mm
U9, U11, U13, U15, U17, U19: SSI2144; SSOP-16_3.9x4.9mm_P0.635mm
Y1: 12MHz; Crystal_SMD_ECS_CSM3X-2Pin_7.6x4.1mm

Connections:
+3V3: C19.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C34.1, J6.1, J9.1, J10.1, L1.1, OC1.8 (VCC), PS2.6 (+Vout), R1.1, R6.1, R16.2, R21.1, U1.1 (~HOLD(IO3)), U1.2 (VCC), U1.3 (~RESET), U1.9 (~WP(IO2)), U3.14 (VDDA), U3.17 (VREFP), U3.18 (VDD(REG)(3V3)), U3.41 (VDD(3V3)), U3.60 (VDD(REG)(3V3)), U3.62 (VDD(3V3)), U3.77 (VDD(3V3)), U3.102 (VDD(3V3)), U3.114 (VDD(3V3)), U3.121 (VDD(REG)(3V3)), U3.138 (VDD(3V3)), U4.20 (VCC), U5.4 (~E0), U5.16 (VCC), U7.6 (GAIN), U7.18 (VLOGIC), U7.20 (~RESET)
+5V: C2.1, C4.1, C6.1, C10.1, C11.1, C12.1, C14.1, C15.1, C16.1, C17.1, C18.1, C20.1, C121.1, C122.1, C123.1, C124.1, C125.1, IC1.11 (V+), IC2.11 (V+), IC3.11 (V+), J8.14, PS1.7 (+Vout), R8.2, R37.1, U2.4 (V+), U6.4 (V+), U7.2 (VDD), U8.1 (VDD), U8.9 (~SHDN), U9.16 (V+), U10.1 (VDD), U10.9 (~SHDN), U11.16 (V+), U12.1 (VDD), U12.9 (~SHDN), U13.16 (V+), U14.1 (VDD), U14.9 (~SHDN), U15.16 (V+), U16.1 (VDD), U16.9 (~SHDN), U17.16 (V+), U18.1 (VDD), U18.9 (~SHDN), U19.16 (V+)
-5V: C3.2, C5.2, C7.2, C21.2, C60.1, C70.1, C80.1, C90.1, C100.1, C110.1, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, IC1.6 (V-), IC2.6 (V-), IC3.6 (V-), PS1.9 (-Vout), R7.2, R57.2, R63.1, R65.2, R74.2, R80.1, R82.2, R91.2, R97.1, R99.2, R108.2, R114.1, R116.2, R125.2, R131.1, R133.2, R142.2, R148.1, R150.2, U2.11 (V-), U6.11 (V-), U9.8 (V-), U11.8 (V-), U13.8 (V-), U15.8 (V-), U17.8 (V-), U19.8 (V-)
/ADC_MIX: R37.2, R38.2, R39.2, R40.2, U4.12 (A10)
/ADC_SPI_MISO: U3.53 (SSP0_MISO), U4.16 (DATA_OUT)
/ADC_SPI_MOSI: U3.54 (SSP0_MOSI), U4.17 (DATA_IN)
/ADC_SPI_SCK: U3.49 (SSP0_SCK), U4.18 (I/O_CLOCK)
/ADC_SPI_SSEL: U3.50 (SSP0_SSEL), U4.15 (~CS)
/DAC_FC0: R52.1, U7.10 (VOUT4)
/DAC_FC1: R86.1, U7.11 (VOUT15)
/DAC_FC2: R120.1, U7.12 (VOUT14)
/DAC_FC3: R69.1, U7.13 (VOUT13)
/DAC_FC4: R103.1, U7.14 (VOUT12)
/DAC_FC5: R137.1, U7.22 (VOUT11)
/DAC_MIXN: C112.1, R10.2, R41.1
/DAC_VCA0: R62.1, U7.1 (VOUT0)
/DAC_VCA1: R96.1, U7.28 (VOUT1)
/DAC_VCA2: R130.1, U7.27 (VOUT2)
/DAC_VCA3: R79.1, U7.26 (VOUT3)
/DAC_VCA4: R113.1, U7.25 (VOUT8)
/DAC_VCA5: R147.1, U7.24 (VOUT9)
/FLASH_SPI_MISO: U1.8 (DO(IO1)), U3.111 (SSP1_MISO)
/FLASH_SPI_MOSI: U1.15 (DI(IO0)), U3.109 (SSP1_MOSI)
/FLASH_SPI_SCK: U1.16 (CLK), U3.112 (SSP1_SCK)
/FLASH_SPI_SSEL: U1.7 (~CS), U3.113 (SSP1_SSEL)
/FOOT_IN: C37.1, R14.1, U3.38 (P3[26])
/KP_1_R1: J7.1, U3.80 (P0[22])
/KP_2_R2: J7.2, U3.82 (P0[21])
/KP_3_R3: J7.3, U3.83 (P0[20])
/KP_4_R4: J7.4, U3.85 (P0[19])
/KP_5_C1: J7.5, U3.69 (P0[10])
/KP_6_C2: J7.6, U3.122 (P4[29])
/KP_7_C3: J7.7, U3.118 (P4[28])
/KP_8_C4: J7.8, U3.71 (P2[13])
/LCD_CTRST: J8.12, R25.1
/LCD_DB4: J8.4, U3.106 (LCD_LE)
/LCD_DB5: J8.3, U3.107 (LCD_PWR)
/LCD_DB6: J8.2, U3.105 (LCD_DCLK)
/LCD_DB7: J8.1, U3.100 (LCD_FP)
/LCD_E1: J8.9, U3.96 (LCD_VD[0])
/LCD_E2: J8.15, U3.95 (LCD_VD[1])
/LCD_RS: J8.11, U3.99 (LCD_ENAB_M)
/LCD_RW: J8.10, U3.97 (LCD_LP)
/MIDI_IN: OC1.6 (VO2), R21.2, U3.70 (P0[11])
/OUT_V0: C61.1, R30.2, R31.2
/OUT_V1: C81.1, R32.2, R33.2
/OUT_V2: C101.1, R28.2, R29.2
/OUT_V3: C71.1, R34.2, R35.2
/OUT_V4: C91.1, R27.2
/OUT_V5: C111.1, R36.2
/PROG_BOOT: J9.6, R6.2, U3.76 (P2[10])
/PROG_RXD: J9.3, U3.142 (U3_RXD)
/PROG_TXD: J9.2, U3.141 (U3_TXD)
/P_0: C43.1, J6.3, U4.1 (A0)
/P_1: C44.1, J6.4, U4.2 (A1)
/P_2: C45.1, J6.5, U4.3 (A2)
/P_3: C46.1, J6.6, U4.4 (A3)
/P_4: C47.1, J6.7, U4.5 (A4)
/P_5: C42.1, J10.3, U4.6 (A5)
/P_6: C41.1, J10.4, U4.7 (A6)
/P_7: C40.1, J10.5, U4.8 (A7)
/P_8: C39.1, J10.6, U4.9 (A8)
/P_9: C38.1, J10.7, U4.11 (A9)
/Power_Supply/D+: J1.3 (D+), R4.2, R5.1, R152.2
/Power_Supply/D-: J1.2 (D-), R2.2
/Power_Supply/USB_5V: C13.1, PS1.1 (+Vin), PS2.1 (+Vin), R5.2, SW2.3 (C), SW2.6 (C)
/Power_Supply/USB_GND: C13.2, J1.4 (GND), PS1.2 (-Vin), PS2.2 (-Vin), R152.1
/Power_Supply/USB_VBUS: J1.1 (VBUS), SW2.2 (B), SW2.5 (B)
/RESET: C8.1, R3.1, U3.24 (~RESET)
/SPI_CS0: U5.15 (~Y0), U7.3 (~SYNC)
/SPI_CS1: U5.14 (~Y1), U8.3 (~CS)
/SPI_CS2: U5.13 (~Y2), U12.3 (~CS)
/SPI_CS3: U5.12 (~Y3), U16.3 (~CS)
/SPI_CS4: U5.11 (~Y4), U10.3 (~CS)
/SPI_CS5: U5.10 (~Y5), U14.3 (~CS)
/SPI_CS6: U5.9 (~Y6), U18.3 (~CS)
/SPI_MUX_A: U3.89 (P0[15]), U5.1 (A0)
/SPI_MUX_B: U3.90 (SSP0_SSEL), U5.2 (A1)
/SPI_MUX_C: U3.115 (P0[5]), U5.3 (A2)
/SPI_SSEL: U3.132 (SSP2_SSEL), U5.6 (E2)
/XTAL1: C1.1, U3.31 (XTAL1), Y1.1
/XTAL2: C9.1, U3.33 (XTAL2), Y1.2
DAC_MIXA: C114.1, R151.1, U8.13 (VrefA), U10.13 (VrefA), U12.13 (VrefA), U14.13 (VrefA), U16.13 (VrefA), U18.13 (VrefA)
DAC_MIXB: C113.1, R42.1, U8.11 (VrefB), U10.11 (VrefB), U12.11 (VrefB), U14.11 (VrefB), U16.11 (VrefB), U18.11 (VrefB)
DAC_RES: R53.1, R70.1, R87.1, R104.1, R121.1, R138.1, U7.9 (VOUT5)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.1, C34.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C54.1, C64.1, C74.1, C84.1, C94.1, C104.1, C112.2, C113.2, C114.2, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, C121.2, C122.2, C123.2, C124.2, C125.2, H1.1, H2.1, H3.1, H4.1, J2.S, J2.SN, J4.S, J4.SN, J5.S, J5.SN, J6.2, J8.13, J9.4, J10.2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
NOISE: C48.2, R49.1, R66.1, R83.1, R100.1, R117.1, R134.1
unnamed: C36.1, R11.1
unnamed: C48.1, R24.2, U2.1
unnamed: C50.2, R45.2, R47.1, U6.7
unnamed: C51.2, R46.2, R48.1, U6.8
unnamed: C52.2, R50.1
unnamed: C53.2, R51.1
unnamed: C59.2, R59.1
unnamed: C60.2, IC1.16, R62.2, R63.2
unnamed: C61.2, IC1.9, R65.1
unnamed: C62.2, R67.1
unnamed: C63.2, R68.1
unnamed: C69.2, R76.1
unnamed: C70.2, IC2.1, R79.2, R80.2
unnamed: C71.2, IC2.8, R82.1
unnamed: C72.2, R84.1
unnamed: C73.2, R85.1
unnamed: C79.2, R93.1
unnamed: C80.2, IC1.1, R96.2, R97.2
unnamed: C81.2, IC1.8, R99.1
unnamed: C82.2, R101.1
unnamed: C83.2, R102.1
unnamed: C89.2, R110.1
unnamed: C90.2, IC3.16, R113.2, R114.2
unnamed: C91.2, IC3.9, R116.1
unnamed: C92.2, R118.1
unnamed: C93.2, R119.1
unnamed: C99.2, R127.1
unnamed: C100.2, IC2.16, R130.2, R131.2
unnamed: C101.2, IC2.9, R133.1
unnamed: C102.2, R135.1
unnamed: C103.2, R136.1
unnamed: C109.2, R144.1
unnamed: C110.2, IC3.1, R147.2, R148.2
unnamed: C111.2, IC3.8, R150.1
unnamed: D1.1 (A), R18.1
unnamed: D1.2 (K), D2.1 (A)
unnamed: D2.2 (K), D3.1 (A), R19.1, U2.3 (+)
unnamed: D3.2 (K), D4.1 (A)
unnamed: D4.2 (K), R20.1
unnamed: D5.1 (A), J3.5, OC1.3 (C2)
unnamed: D5.2 (K), OC1.2 (C1), R26.2
unnamed: IC1.5, IC1.7, R98.1
unnamed: IC1.10, IC1.12, R64.1
unnamed: IC1.14 (+), R59.2, R61.2
unnamed: IC1.13 (-), R60.1
unnamed: IC1.3 (+), R93.2, R95.2
unnamed: IC1.4 (-), R94.1
unnamed: IC2.5, IC2.7, R81.1
unnamed: IC2.10, IC2.12, R132.1
unnamed: IC2.14 (+), R127.2, R129.2
unnamed: IC2.13 (-), R128.1
unnamed: IC2.3 (+), R76.2, R78.2
unnamed: IC2.4 (-), R77.1
unnamed: IC3.5, IC3.7, R149.1
unnamed: IC3.10, IC3.12, R115.1
unnamed: IC3.14 (+), R110.2, R112.2
unnamed: IC3.13 (-), R111.1
unnamed: IC3.3 (+), R144.2, R146.2
unnamed: IC3.4 (-), R145.1
unnamed: J2.T, J2.TN, R14.2, R16.1
unnamed: J3.4, R26.1
unnamed: J4.R, J5.TN
unnamed: J4.T, R47.2
unnamed: J4.TN, J5.R
unnamed: J5.T, R48.2
unnamed: OC1.7 (VO1), R22.2
unnamed: C33.2, Q1.1 (B), R7.1
unnamed: C35.1, Q1.2 (E), R8.1
unnamed: R1.2, R3.2, SW1.2
unnamed: R15.2, R19.2, U2.14
unnamed: R17.1, R20.2, U2.7
unnamed: R38.1, R43.2, RV1.1, U6.1
unnamed: R39.1, R44.2, RV1.4, U6.14
unnamed: R23.2, R24.1, U2.2 (-)
unnamed: R13.2, R17.2, U2.6 (-)
unnamed: R10.1, R12.2, U2.10 (+)
unnamed: R13.1, R18.2, U2.8, U2.9 (-)
unnamed: C35.2, R9.2, U2.12 (+)
unnamed: R11.2, R15.1, U2.13 (-)
unnamed: R25.2, U3.8 (P0[26])
unnamed: C49.1, L1.2, U4.14 (REF+)
unnamed: R27.1, R28.1, R30.1, R32.1, R34.1, R43.1, U6.2 (-)
unnamed: RV1.2, U6.5 (+)
unnamed: C50.1, R45.1, U6.6 (-)
unnamed: RV1.5, U6.10 (+)
unnamed: C51.1, R46.1, U6.9 (-)
unnamed: R29.1, R31.1, R33.1, R35.1, R36.1, R44.1, U6.13 (-)
unnamed: R151.2, U7.8 (VOUT6)
unnamed: R42.2, U7.7 (VOUT7)
unnamed: R41.2, U7.23 (VOUT10)
unnamed: C52.1, U8.14 (VoutA)
unnamed: C53.1, U8.10 (VoutB)
unnamed: C55.2, U9.13 (C1A)
unnamed: C55.1, U9.12 (C1B)
unnamed: C56.2, U9.11 (C2A)
unnamed: C56.1, U9.10 (C2B)
unnamed: C57.1, U9.6 (C3A)
unnamed: C57.2, U9.7 (C3B)
unnamed: C58.1, U9.4 (C4A)
unnamed: C58.2, U9.5 (C4B)
unnamed: C54.2, R52.2, R55.1, R57.1, U9.15 (FREQ_CTRL)
unnamed: C59.1, R58.1, U9.3 (OUT)
unnamed: R53.2, U9.14 (Q_CTRL)
unnamed: R49.2, R50.2, R51.2, R54.2, U9.1 (SIG_IN+)
unnamed: R56.2, U9.2 (SIG_IN-)
unnamed: C62.1, U10.14 (VoutA)
unnamed: C63.1, U10.10 (VoutB)
unnamed: C65.2, U11.13 (C1A)
unnamed: C65.1, U11.12 (C1B)
unnamed: C66.2, U11.11 (C2A)
unnamed: C66.1, U11.10 (C2B)
unnamed: C67.1, U11.6 (C3A)
unnamed: C67.2, U11.7 (C3B)
unnamed: C68.1, U11.4 (C4A)
unnamed: C68.2, U11.5 (C4B)
unnamed: C64.2, R69.2, R72.1, R74.1, U11.15 (FREQ_CTRL)
unnamed: C69.1, R75.1, U11.3 (OUT)
unnamed: R70.2, U11.14 (Q_CTRL)
unnamed: R66.2, R67.2, R68.2, R71.2, U11.1 (SIG_IN+)
unnamed: R73.2, U11.2 (SIG_IN-)
unnamed: C72.1, U12.14 (VoutA)
unnamed: C73.1, U12.10 (VoutB)
unnamed: C75.2, U13.13 (C1A)
unnamed: C75.1, U13.12 (C1B)
unnamed: C76.2, U13.11 (C2A)
unnamed: C76.1, U13.10 (C2B)
unnamed: C77.1, U13.6 (C3A)
unnamed: C77.2, U13.7 (C3B)
unnamed: C78.1, U13.4 (C4A)
unnamed: C78.2, U13.5 (C4B)
unnamed: C74.2, R86.2, R89.1, R91.1, U13.15 (FREQ_CTRL)
unnamed: C79.1, R92.1, U13.3 (OUT)
unnamed: R87.2, U13.14 (Q_CTRL)
unnamed: R83.2, R84.2, R85.2, R88.2, U13.1 (SIG_IN+)
unnamed: R90.2, U13.2 (SIG_IN-)
unnamed: C82.1, U14.14 (VoutA)
unnamed: C83.1, U14.10 (VoutB)
unnamed: C85.2, U15.13 (C1A)
unnamed: C85.1, U15.12 (C1B)
unnamed: C86.2, U15.11 (C2A)
unnamed: C86.1, U15.10 (C2B)
unnamed: C87.1, U15.6 (C3A)
unnamed: C87.2, U15.7 (C3B)
unnamed: C88.1, U15.4 (C4A)
unnamed: C88.2, U15.5 (C4B)
unnamed: C84.2, R103.2, R106.1, R108.1, U15.15 (FREQ_CTRL)
unnamed: C89.1, R109.1, U15.3 (OUT)
unnamed: R104.2, U15.14 (Q_CTRL)
unnamed: R100.2, R101.2, R102.2, R105.2, U15.1 (SIG_IN+)
unnamed: R107.2, U15.2 (SIG_IN-)
unnamed: C92.1, U16.14 (VoutA)
unnamed: C93.1, U16.10 (VoutB)
unnamed: C95.2, U17.13 (C1A)
unnamed: C95.1, U17.12 (C1B)
unnamed: C96.2, U17.11 (C2A)
unnamed: C96.1, U17.10 (C2B)
unnamed: C97.1, U17.6 (C3A)
unnamed: C97.2, U17.7 (C3B)
unnamed: C98.1, U17.4 (C4A)
unnamed: C98.2, U17.5 (C4B)
unnamed: C94.2, R120.2, R123.1, R125.1, U17.15 (FREQ_CTRL)
unnamed: C99.1, R126.1, U17.3 (OUT)
unnamed: R121.2, U17.14 (Q_CTRL)
unnamed: R117.2, R118.2, R119.2, R122.2, U17.1 (SIG_IN+)
unnamed: R124.2, U17.2 (SIG_IN-)
unnamed: C102.1, U18.14 (VoutA)
unnamed: C103.1, U18.10 (VoutB)
unnamed: C105.2, U19.13 (C1A)
unnamed: C105.1, U19.12 (C1B)
unnamed: C106.2, U19.11 (C2A)
unnamed: C106.1, U19.10 (C2B)
unnamed: C107.1, U19.6 (C3A)
unnamed: C107.2, U19.7 (C3B)
unnamed: C108.1, U19.4 (C4A)
unnamed: C108.2, U19.5 (C4B)
unnamed: C104.2, R137.2, R140.1, R142.1, U19.15 (FREQ_CTRL)
unnamed: C109.1, R143.1, U19.3 (OUT)
unnamed: R138.2, U19.14 (Q_CTRL)
unnamed: R134.2, R135.2, R136.2, R139.2, U19.1 (SIG_IN+)
unnamed: R141.2, U19.2 (SIG_IN-)
SPI_MOSI: U3.135 (SSP2_MOSI), U7.5 (SDI), U8.5 (SDI), U10.5 (SDI), U12.5 (SDI), U14.5 (SDI), U16.5 (SDI), U18.5 (SDI)
SPI_SCK: U3.136 (SSP2_SCK), U7.4 (SCLK), U8.4 (SCK), U10.4 (SCK), U12.4 (SCK), U14.4 (SCK), U16.4 (SCK), U18.4 (SCK)
USB_D+: R4.1, U3.42 (P0[29])
USB_D-: R2.1, U3.43 (P0[30])

File hardware/jlcpcb/production_files/BOM-overcycler3.csv:

Comment,Designator,Footprint,LCSC
FerriteBead,FB1,L_0805_2012Metric,C1017
10n,"C105,C106,C107,C55,C56,C57,C65,C66,C67,C75,C76,C77,C85,C86,C87,C95,C96,C97",C_0603_1608Metric,C115056
470n,"C100,C104,C110,C54,C60,C64,C70,C74,C80,C84,C90,C94",C_0805_2012Metric,C13967
100k,"R15,R24",R_0805_2012Metric,C149504
100u,"C101,C111,C33,C36,C48,C61,C71,C81,C91",CP_EIA-3528-21_Kemet-B,C16133
10n,"C2,C3,C4,C5,C6,C7",C_0805_2012Metric,C1710
10k,"R110,R12,R127,R13,R14,R144,R17,R3,R59,R7,R76,R93",R_0805_2012Metric,C17414
120k,"R29,R34",R_0805_2012Metric,C17436
15k,"R101,R102,R104,R108,R118,R119,R121,R125,R135,R136,R138,R142,R43,R44,R50,R51,R53,R57,R67,R68,R70,R74,R84,R85,R87,R91",R_0805_2012Metric,C17475
1k,"R1,R11,R37,R40,R6",R_0805_2012Metric,C17513
1M,R9,R_0805_2012Metric,C17514
2k2,"R38,R39",R_0805_2012Metric,C17520
220k,R8,R_0805_2012Metric,C17556
220,R26,R_0805_2012Metric,C17557
22k,"R100,R115,R117,R132,R134,R149,R49,R64,R66,R81,R83,R98",R_0805_2012Metric,C17560
270,R21,R_0805_2012Metric,C17590
27k,R10,R_0805_2012Metric,C17593
330,"R47,R48",R_0805_2012Metric,C17630
33k,"R27,R36",R_0805_2012Metric,C17633
33,"R2,R4",R_0805_2012Metric,C17634
390,"R106,R123,R140,R55,R72,R89",R_0805_2012Metric,C17655
4k7,"R109,R113,R116,R126,R130,R133,R143,R147,R150,R16,R22,R23,R42,R58,R62,R65,R75,R79,R82,R92,R96,R99",R_0805_2012Metric,C17673
470,"R111,R112,R128,R129,R145,R146,R18,R20,R25,R60,R61,R77,R78,R94,R95",R_0805_2012Metric,C17710
47k,"R28,R35,R45,R46",R_0805_2012Metric,C17713
56k,"R30,R33",R_0805_2012Metric,C17756
6k8,"R103,R120,R137,R52,R69,R86",R_0805_2012Metric,C17772
820,"R105,R107,R114,R122,R124,R131,R139,R141,R148,R54,R56,R63,R71,R73,R80,R88,R90,R97",R_0805_2012Metric,C17837
82k,"R31,R32",R_0805_2012Metric,C17840
100p,"C50,C51",C_0805_2012Metric,C1790
22p,"C1,C9",C_0805_2012Metric,C1804
2SC945,Q1,SOT-23,C181154
100n,"C10,C11,C12,C14,C15,C16,C17,C18,C19,C20,C23,C24,C25,C26,C27,C29,C30,C32,C34,C35,C37,C38,C39,C40,C41,C42,C43,C44,C45,C46,C47,C49,C8",C_0805_2012Metric,C28233
AD5328B,"U20,U7",TSSOP-16_4.4x5mm_P0.65mm,C29162
DIN-5_180degree,J3,DIN-5-180,C2939344
12MHz,Y1,Crystal_SMD_ECS_CSM3X-2Pin_7.6x4.1mm,C2975358
PANEL,P2,IDC-Header_2x20_P2.54mm_Vertical,C3013500
AudioJack3_Switch,"J2,J4,J5",Jack_6.35mm_Neutrik_NMJ6HFD2_Horizontal,C309275
3M3,R19,R_0805_2012Metric,C34154
10k,RV1,Potentiometer_Alps_RK163_Dual_Horizontal,C370979
LPC1778FBD144,U3,LQFP-144_20x20mm_P0.5mm,C37701
POWER,SW2,SPUN192600,C390926
MCP4922-ESL,"U10,U12,U14,U16,U18,U8",SO-14_3.9x8.65mm_P1.27mm,C39851
6N139,OC1,DIP-8_W7.62mm,C4071
FT232,P1,PinSocket_1x06_P2.54mm_Vertical,C40877
RESET,SW1,SW_PUSH_6mm,C428628
1k5,R5,R_0805_2012Metric,C4310
22u,"C102,C103,C52,C53,C62,C63,C72,C73,C82,C83,C92,C93",C_0805_2012Metric,C45783
LM13700,"IC1,IC2,IC3",SO-16_3.9x9.9mm_P1.27mm,C5160094
820p,"C108,C58,C68,C78,C88,C98",C_0603_1608Metric,C519567
IA0505S-2W,PS1,IA0505S-2W,C5198614
IB0503LSY-1WR1,PS2,IB0503LSY,C5198623
TLV2556,U4,SOIC-20W_7.5x12.8mm_P1.27mm,C527513
XT26G02CWSIGA,U1,WSON-8-1EP_8x6mm_P1.27mm_EP3.4x4.3mm,C5362272
74HC138,U5,SO-16_3.9x9.9mm_P1.27mm,C5602
470u,C13,CP_EIA-7343-43_Kemet-X,C561869
TL074,"U2,U6",SO-14_3.9x8.65mm_P1.27mm,C6964
10u,"C21,C22,C31",CP_EIA-3216-18_Kemet-A,C7171
USB_B,J1,USB_B_Lumberg_2411_02_Horizontal,C720549
1N4148,"D1,D2,D3,D4,D5",D_SOD-123,C81598
47u,"C109,C59,C69,C79,C89,C99",C_1206_3216Metric,C96123
SSI2144,"U11,U13,U15,U17,U19,U9",SSOP-16_3.9x4.9mm_P0.635mm,C9900070109
