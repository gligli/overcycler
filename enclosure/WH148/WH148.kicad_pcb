# Repository gligli/overcycler (continued)

## KiCad design hardware/overcycler2.kicad_pcb

Board: 2 copper layers, 279 parts (3 on the bottom side), 260 nets.

Parts:
C1, C28, C29, C33: 10u; C1V5
C2, C3, C4, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C26, C27, C30: 100n; C2
C5, C23, C42, C51, C60, C69, C78, C87, C95: 100u; C1.5V8V
C6, C7, C8, C9, C10, C11, C37, C38, C39, C46, C47, C48, C55, C56, C57, C64, C65, C66, C73, C74, C75, C82, C83, C84: 10n; C2
C24, C25: 10000u 16v; Elko_vert_DM16_RM7-5_CopperClear
C31, C32: 100p; C2
C34, C35, C43, C44, C52, C53, C61, C62, C70, C71, C79, C80: 22u; C1V7
C36, C45, C54, C63, C72, C81: 820p; B32520-3
C40, C49, C58, C67, C76, C85: 33u; C1.5V8V
C41, C50, C59, C68, C77, C86, C89, C90, C91, C92, C93, C94: 470n; C2
C88: 2u2; C1V5
D1, D6, D7: 1N5819; D3
D2, D3, D4, D5: 1N4148; D3
HOLE1, HOLE2, HOLE3, HOLE4: P***; 1pin
IC1, IC2, IC3: LM13700; DIP-16__300_ELL
OC1: 6N139; optocoupler-DIL08
P1: LPC_P1; SIL-33
P2: LPC_P2; SIL-33
P3: FT232; SIL-6
P4: PANEL; CONN40
P5: SDCARD; SIL-7
P6: MIDI_IN; SIL-2
P7: FOOT_IN; SIL-2
P8: AC_IN; bornier2
P9: AUDIO_OUT; SIL-8
Q1: BC547; TO92
R1: 270; R3-LARGE_PADS
R2, R7, R18, R44, R47, R50, R59, R62, R65, R74, R77, R80, R89, R92, R95, R104, R107, R110, R119, R122, R125: 4k7; R3-LARGE_PADS
R3, R126: 220; R3-LARGE_PADS
R4, R10, R34, R35, R130: 1k; R3-LARGE_PADS
R5, R11, R12, R14, R46, R61, R76, R91, R106, R121, R128, R129: 10k; R3-LARGE_PADS
R6: 470k; R3-LARGE_PADS
R8: 1M; R3-LARGE_PADS
R9: 27k; R3-LARGE_PADS
R13, R19: 100k; R3-LARGE_PADS
R15, R17: 470; R3-LARGE_PADS
R16: 3M3; R3-LARGE_PADS
R20, R29: 33k; R3-LARGE_PADS
R21, R28, R32, R33: 47k; R3-LARGE_PADS
R22, R27: 150k; R3-LARGE_PADS
R23, R26: 56k; R3-LARGE_PADS
R24, R25: 68k; R3-LARGE_PADS
R30, R31, R37, R38, R40, R45, R52, R53, R55, R60, R67, R68, R70, R75, R82, R83, R85, R90, R97, R98, R100, R105, R112, R113, R115, R120: 15k; R3-LARGE_PADS
R36, R49, R51, R64, R66, R79, R81, R94, R96, R109, R111, R124: 22k; R3-LARGE_PADS
R39, R42, R48, R54, R57, R63, R69, R72, R78, R84, R87, R93, R99, R102, R108, R114, R117, R123: 820; R3-LARGE_PADS
R41, R56, R71, R86, R101, R116: 6k8; R3-LARGE_PADS
R43, R58, R73, R88, R103, R118: 390; R3-LARGE_PADS
R127: 120; R3-LARGE_PADS
RV1: 10k; RV2X1.5
RV2, RV3, RV4, RV5, RV6, RV7: 1k; RV2X1.5
SW1: RESET; SW_PUSH_SMALL
U1: TLV1543; DIP-20__300_ELL
U2: 74HC138; DIP-16__300_ELL
U3, U4: LTC1660; DIP-16__300_ELL
U5, U6: TL074; DIP-14__300_ELL
U7: LM1084IT-5.0/NOPB; TO220_VERT_FIXED
U8: LM2990-5.0/NOPB; TO220_VERT_FIXED
U9: LM1084IT-ADJ/NOPB; TO220_VERT_FIXED
U10, U12, U14, U16, U18, U20: MCP4922-E/P; DIP-14__300_ELL
U11, U13, U15, U17, U19, U21: SSM2044; DIP-16__300_ELL

Connections:
+3.3V: C20.1, C21.1, C22.1, C33.1, OC1.8, P2.1, P3.1, P4.17, P4.30, P5.4, R1.1, R7.2, R127.2, R128.1, R130.1, U1.14, U1.20, U2.6, U2.16, U9.2
+5V: C6.1, C8.1, C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C28.1, C30.1, IC1.11, IC2.11, IC3.11, P1.2, P4.14, R4.1, R6.2, RV1.3, U3.11, U3.16, U4.11, U4.16, U5.4, U6.4, U7.2, U9.3, U10.1, U10.9, U11.16, U12.1, U12.9, U13.16, U14.1, U14.9, U15.16, U16.1, U16.9, U17.16, U18.1, U18.9, U19.16, U20.1, U20.9, U21.16
-5V: C7.2, C9.2, C11.2, C29.2, C41.1, C50.1, C59.1, C68.1, C77.1, C86.1, IC1.6, IC2.6, IC3.6, R45.2, R48.1, R50.2, R60.2, R63.1, R65.2, R75.2, R78.1, R80.2, R90.2, R93.1, R95.2, R105.2, R108.1, R110.2, R120.2, R123.1, R125.2, R129.2, U5.11, U6.11, U8.3, U11.9, U13.9, U15.9, U17.9, U19.9, U21.9
/AC_IN: D6.1, D7.2, P8.1
/ADC_ADDR: P1.18, U1.17
/ADC_CLK: P2.13, R130.2, U1.18
/ADC_CS: P1.16, U1.15
/ADC_EOC: P2.14, U1.19
/ADC_OUT: P1.17, U1.16
/DAC_MIXN: R9.2, U3.14
/DAC_VREF: C1.1, C2.1, R4.2, U3.6, U4.6
/FOOT_IN: C3.1, P1.22, R5.1
/KP_1_R1: P2.24, P4.19
/KP_2_R2: P2.23, P4.21
/KP_3_R3: P2.22, P4.23
/KP_4_R4: P2.21, P4.25
/KP_5_C1: P2.25, P4.20
/KP_6_C2: P2.26, P4.22
/KP_7_C3: P2.29, P4.24
/KP_8_C4: P2.20, P4.26
/LCD_DB4: P2.15, P4.4
/LCD_DB5: P2.16, P4.3
/LCD_DB6: P2.17, P4.2
/LCD_DB7: P2.18, P4.1
/LCD_E1: P1.26, P4.9
/LCD_E2: P1.25, P4.15
/LCD_RS: P2.19, P4.11
/LCD_RW: P1.27, P4.10
/MIDI_IN: OC1.6, P2.28, R1.2
/P_0: P4.32, U1.1
/P_1: P4.34, U1.2
/P_2: P4.36, U1.3
/P_3: P4.38, U1.4
/P_4: P4.40, U1.5
/P_5: P4.39, U1.6
/P_6: P4.37, U1.7
/P_7: P4.35, U1.8
/P_8: P4.33, U1.9
/P_9: P4.31, U1.11
/SPI_CS6: U2.9, U3.7
/SPI_CS7: U2.7, U4.7
/SPI_MUX_A: P1.13, U2.1
/SPI_MUX_B: P1.14, U2.2
/SPI_MUX_C: P2.12, U2.3
/SPI_SSEL: P2.31, U2.4
/UNR+: C24.1, C26.1, D6.2, U7.3
/UNR-: C25.2, C27.2, D7.1, U8.2
/Voice #0/DAC_FC: R41.1, U4.2
/Voice #0/DAC_VCA: R47.1, U3.2
/Voice #0/OUT: C42.1, R23.2, R24.2
/Voice #0/SPI_CS: U2.15, U10.3
/Voice #1/DAC_FC: R56.1, U4.3
/Voice #1/DAC_VCA: R62.1, U3.3
/Voice #1/OUT: C51.1, R25.2, R26.2
/Voice #1/SPI_CS: U2.14, U12.3
/Voice #2/DAC_FC: R71.1, U4.4
/Voice #2/DAC_VCA: R77.1, U3.4
/Voice #2/OUT: C60.1, R21.2, R22.2
/Voice #2/SPI_CS: U2.13, U14.3
/Voice #3/DAC_FC: R86.1, U4.5
/Voice #3/DAC_VCA: R92.1, U3.5
/Voice #3/OUT: C69.1, R27.2, R28.2
/Voice #3/SPI_CS: U2.12, U16.3
/Voice #4/DAC_FC: R101.1, U4.12
/Voice #4/DAC_VCA: R107.1, U3.12
/Voice #4/OUT: C78.1, R20.2
/Voice #4/SPI_CS: U2.11, U18.3
/Voice #5/DAC_FC: R116.1, U4.13
/Voice #5/DAC_VCA: R122.1, U3.13
/Voice #5/OUT: C87.1, R29.2
/Voice #5/SPI_CS: U2.10, U20.3
DAC_MIXA: U4.14, U10.13, U12.13, U14.13, U16.13, U18.13, U20.13
DAC_MIXB: U4.15, U10.11, U12.11, U14.11, U16.11, U18.11, U20.11
DAC_RES: R40.1, R55.1, R70.1, R85.1, R100.1, R115.1, U3.15
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.1, C8.2, C9.1, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C24.2, C25.1, C26.2, C27.1, C28.2, C29.1, C30.2, C33.2, C88.2, C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, C95.1, OC1.5, P1.1, P3.4, P4.13, P4.18, P4.27, P4.28, P4.29, P5.3, P7.2, P8.2, P9.3, P9.6, R2.1, R8.1, R11.1, R18.1, R39.1, R42.1, R43.2, R44.2, R49.2, R54.1, R57.1, R58.2, R59.2, R64.2, R69.1, R72.1, R73.2, R74.2, R79.2, R84.1, R87.1, R88.2, R89.2, R94.2, R99.1, R102.1, R103.2, R104.2, R109.2, R114.1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
unnamed: R12.2, R14.2, U5.9
unnamed: R14.1, R17.2, U5.8
unnamed: R12.1, R15.2, U5.6, U5.7
unnamed: R9.1, R11.2, U5.5
unnamed: C4.1, Q1.3, R6.1
unnamed: P9.2, U6.5
unnamed: P9.5, U6.10
unnamed: P9.1, R30.1, U6.1
unnamed: P9.4, R31.1, U6.14
unnamed: D4.2, D5.1
unnamed: C23.1, R19.2, U5.14
unnamed: D5.2, R17.1
unnamed: D2.2, D3.1
unnamed: D2.1, R15.1
unnamed: D3.2, D4.1, R16.1, U5.12
unnamed: C4.2, R8.2, U5.3
unnamed: R10.2, R13.1, U5.2
unnamed: R13.2, R16.2, U5.1
unnamed: C5.1, R10.1
unnamed: R18.2, R19.1, U5.13
unnamed: P1.6, P5.7
unnamed: P1.7, P5.5
unnamed: P1.5, P5.2
unnamed: D1.2, OC1.2, R3.2
unnamed: P1.9, P3.2
unnamed: P1.10, P3.3
unnamed: P2.11, P3.6
unnamed: P1.8, P5.1
unnamed: D1.1, OC1.3, P6.2
unnamed: P6.1, R3.1
unnamed: OC1.7, R2.2
unnamed: P7.1, R5.2, R7.1
unnamed: C88.1, P1.4, R128.2, SW1.2
unnamed: R126.2, R127.1, U9.1
unnamed: C95.2, Q1.2, R129.1
unnamed: C32.2, R33.2, R34.2, U6.8
unnamed: C31.2, R32.2, R35.2, U6.7
unnamed: C31.1, R32.1, U6.6
unnamed: C32.1, R33.1, U6.9
unnamed: R20.1, R21.1, R23.1, R25.1, R27.1, R30.2, U6.2
unnamed: R22.1, R24.1, R26.1, R28.1, R29.1, R31.2, U6.13
unnamed: P9.7, R35.1
unnamed: P9.8, R34.1
unnamed: P4.12, RV1.2
unnamed: R36.2, R37.2, R38.2, R39.2, U11.1
unnamed: C34.1, U10.14
unnamed: C35.1, U10.10
unnamed: C35.2, R38.1
unnamed: C34.2, R37.1
unnamed: C36.1, U11.4
unnamed: R40.2, U11.2
unnamed: C37.2, U11.7
unnamed: C39.1, U11.10
unnamed: R42.2, U11.15
unnamed: C38.2, U11.14
unnamed: C38.1, U11.12
unnamed: C39.2, U11.11
unnamed: C40.1, R44.1, U11.3
unnamed: C89.2, R41.2, R43.1, R45.1, U11.13
unnamed: C41.2, IC1.16, R47.2, R48.2
unnamed: IC1.13, RV2.3
unnamed: IC1.10, IC1.12, R49.1
unnamed: C42.2, IC1.9, R50.1
unnamed: C40.2, R46.1
unnamed: C36.2, U11.5
unnamed: C37.1, U11.6
unnamed: IC1.14, R46.2, RV2.1
unnamed: R51.2, R52.2, R53.2, R54.2, U13.1
unnamed: C43.1, U12.14
unnamed: C44.1, U12.10
unnamed: C44.2, R53.1
unnamed: C43.2, R52.1
unnamed: C45.1, U13.4
unnamed: R55.2, U13.2
unnamed: C46.2, U13.7
unnamed: C48.1, U13.10
unnamed: C47.2, U13.14
unnamed: C47.1, U13.12
unnamed: C48.2, U13.11
unnamed: R57.2, U13.15
unnamed: C49.1, R59.1, U13.3
unnamed: C90.2, R56.2, R58.1, R60.1, U13.13
unnamed: C50.2, IC1.1, R62.2, R63.2
unnamed: IC1.4, RV3.3
unnamed: IC1.5, IC1.7, R64.1
unnamed: C51.2, IC1.8, R65.1
unnamed: C49.2, R61.1
unnamed: C45.2, U13.5
unnamed: C46.1, U13.6
unnamed: IC1.3, R61.2, RV3.1
unnamed: R66.2, R67.2, R68.2, R69.2, U15.1
unnamed: C57.1, U15.10
unnamed: C52.1, U14.14
unnamed: C53.1, U14.10
unnamed: C53.2, R68.1
unnamed: C52.2, R67.1
unnamed: C54.1, U15.4
unnamed: R70.2, U15.2
unnamed: C55.2, U15.7
unnamed: C56.1, U15.12
unnamed: C57.2, U15.11
unnamed: R72.2, U15.15
unnamed: C56.2, U15.14
unnamed: C58.1, R74.1, U15.3
unnamed: C91.2, R71.2, R73.1, R75.1, U15.13
unnamed: C59.2, IC2.16, R77.2, R78.2
unnamed: IC2.13, RV4.3
unnamed: IC2.10, IC2.12, R79.1
unnamed: C60.2, IC2.9, R80.1
unnamed: C58.2, R76.1
unnamed: C54.2, U15.5
unnamed: C55.1, U15.6
unnamed: IC2.14, R76.2, RV4.1
unnamed: R81.2, R82.2, R83.2, R84.2, U17.1
unnamed: R85.2, U17.2
unnamed: C61.1, U16.14
unnamed: C62.1, U16.10
unnamed: C62.2, R83.1
unnamed: C61.2, R82.1
unnamed: C63.1, U17.4
unnamed: C65.2, U17.14
unnamed: C64.2, U17.7
unnamed: C65.1, U17.12
unnamed: C66.2, U17.11
unnamed: C66.1, U17.10
unnamed: R87.2, U17.15
unnamed: C67.1, R89.1, U17.3
unnamed: C92.2, R86.2, R88.1, R90.1, U17.13
unnamed: C68.2, IC2.1, R92.2, R93.2
unnamed: IC2.4, RV5.3
unnamed: IC2.5, IC2.7, R94.1
unnamed: C69.2, IC2.8, R95.1
unnamed: C67.2, R91.1
unnamed: C63.2, U17.5
unnamed: C64.1, U17.6
unnamed: IC2.3, R91.2, RV5.1
unnamed: R96.2, R97.2, R98.2, R99.2, U19.1
unnamed: C74.2, U19.14
unnamed: C70.1, U18.14
unnamed: C71.1, U18.10
unnamed: C71.2, R98.1
unnamed: C70.2, R97.1
unnamed: C72.1, U19.4
unnamed: R100.2, U19.2
unnamed: C75.1, U19.10
unnamed: C73.2, U19.7
unnamed: C74.1, U19.12
unnamed: C75.2, U19.11
unnamed: R102.2, U19.15
unnamed: C76.1, R104.1, U19.3
unnamed: C93.2, R101.2, R103.1, R105.1, U19.13
unnamed: C77.2, IC3.16, R107.2, R108.2
unnamed: IC3.13, RV6.3
unnamed: IC3.10, IC3.12, R109.1
unnamed: C78.2, IC3.9, R110.1
unnamed: C76.2, R106.1
unnamed: C72.2, U19.5
unnamed: C73.1, U19.6
unnamed: IC3.14, R106.2, RV6.1
unnamed: R111.2, R112.2, R113.2, R114.2, U21.1
unnamed: C79.1, U20.14
unnamed: C80.1, U20.10
unnamed: C80.2, R113.1
unnamed: C79.2, R112.1
unnamed: C81.1, U21.4
unnamed: R115.2, U21.2
unnamed: C82.2, U21.7
unnamed: C84.1, U21.10
unnamed: C83.2, U21.14
unnamed: C83.1, U21.12
unnamed: C84.2, U21.11
unnamed: R117.2, U21.15
unnamed: C85.1, R119.1, U21.3
unnamed: C94.2, R116.2, R118.1, R120.1, U21.13
unnamed: C86.2, IC3.1, R122.2, R123.2
unnamed: IC3.4, RV7.3
unnamed: IC3.5, IC3.7, R124.1
unnamed: C87.2, IC3.8, R125.1
unnamed: C85.2, R121.1
unnamed: C81.2, U21.5
unnamed: C82.1, U21.6
unnamed: IC3.3, R121.2, RV7.1
NOISE: C23.2, R36.1, R51.1, R66.1, R81.1, R96.1, R111.1
SPI_MOSI: P2.33, U3.9, U4.9, U10.5, U12.5, U14.5, U16.5, U18.5, U20.5
SPI_SCK: P2.30, U3.8, U4.8, U10.4, U12.4, U14.4, U16.4, U18.4, U20.4

## KiCad design hardware/overcycler.kicad_pcb

Board: 2 copper layers, 99.1 x 109.2 mm, 43 parts (0 on the bottom side), 60 nets.

Parts:
C3, C9, C10, C11: 100n; C2
C4, C5: 10000u; C2V10
C6, C8: 6u8; C1V8
C7: 4u7; C1V8
D1, D2, D3: 1N5819; D3
HOLE1, HOLE2: P***; 1pin
OC1: 6N139; optocoupler-DIL08
P1: LPC_P1; SIL-33
P2: LPC_P2; SIL-33
P3: FT232; SIL-6
P4: CARD0_CMD_PWR; SIL-14
P5: SDCARD; SIL-7
P6: CARD1_CMD_PWR; SIL-14
P7: SCREEN; SIL-5
P8: CARD2_CMD_PWR; SIL-14
P9: TEN_POTS; pin_array_6x2
P10: VCA_CMD_PWR; SIL-9
P11: AC_IN; bornier2
P12: FOOT_IN; SIL-2
P13: MIDI_IN; SIL-2
P14: VCA_SPI; SIL-5
R1: 33k; R3-LARGE_PADS
R2: 270; R3-LARGE_PADS
R3, R6: 4k7; R3-LARGE_PADS
R4: 10k; R3-LARGE_PADS
R5: 220; R3-LARGE_PADS
RV1: 10k; RV2X1.5
SW1: RESET; SW_PUSH_SMALL
U1, U2: 4053; DIP-16__300_ELL
U3: MCP4921-E/P; DIP-8__300_ELL
U4: LM1084IT-5.0/NOPB; TO220_VERT_FIXED
U5: LM2990-5.0/NOPB; TO220_VERT_FIXED
U6: LM1084IT-3.3/NOPB; TO220_VERT_FIXED

Connections:
+3.3V: C8.1, C10.1, C11.1, OC1.8, P2.1, P3.1, P5.4, P9.1, R2.1, U1.16, U2.16, U6.2
+5V: C3.1, C6.1, P1.2, P4.12, P6.12, P7.3, P8.12, P10.6, R6.2, RV1.3, U3.1, U4.2
-5V: C7.2, P4.14, P6.14, P8.14, P10.7, U5.3
/AC_IN: D1.1, D2.2, P11.1
/FOOT_IN: C9.1, P1.22, R4.1
/MIDI_IN: OC1.6, P2.28, R2.2
/UNR+: C4.1, D1.2, U4.3, U6.3
/UNR-: C5.2, D2.1, U5.2
GND: C3.2, C4.2, C5.1, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, OC1.5, P1.1, P2.27, P3.4, P4.13, P5.3, P6.13, P7.4, P7.5, P8.13, P9.2, P10.8, P10.9, P11.2, P12.2, R1.1, R3.1, SW1.1, U1.6, U1.7, U1.8, U2.3, U2.4, U2.5, U2.6, U2.7, U2.8, U3.7, U4.1, U5.1, U6.1
unnamed: P2.11, P3.6
unnamed: P9.8, U2.13
unnamed: P9.4, U2.1
unnamed: P9.7, U1.2
unnamed: P1.20, U2.15
unnamed: P1.18, U2.14
unnamed: P9.3, U1.12
unnamed: P9.5, U1.13
unnamed: P9.9, U1.1
unnamed: P9.11, U1.5
unnamed: P9.12, U1.3
unnamed: P9.10, U2.12
unnamed: P2.33, P4.8, P6.8, P8.8, P14.1, U3.4
unnamed: P2.30, P4.7, P6.7, P8.7, P14.2, U3.3
unnamed: P2.31, P4.6, P6.6, P8.6, P14.3, U3.2
unnamed: P2.29, P10.5
unnamed: D3.2, OC1.2, R5.2
unnamed: D3.1, OC1.3, P13.2
unnamed: OC1.7, R3.2
unnamed: P2.21, P4.3, P6.3, P8.3, P10.3
unnamed: P2.22, P4.2, P6.2, P8.2, P10.2
unnamed: P1.8, P5.1
unnamed: P1.5, P5.2
unnamed: P1.6, P5.7
unnamed: P1.7, P5.5
unnamed: P1.4, SW1.2
unnamed: P1.13, P7.1
unnamed: P1.10, P3.3
unnamed: P1.9, P3.2
unnamed: P1.21, U1.9, U1.10, U1.11, U2.9, U2.10, U2.11
unnamed: P1.14, P7.2
unnamed: P1.15, U1.14
unnamed: P1.16, U1.15
unnamed: P1.17, U1.4
unnamed: RV1.2, U3.6
unnamed: R1.2, RV1.1
unnamed: P13.1, R5.1
unnamed: P1.25, P8.9
unnamed: P1.26, U3.5
unnamed: P9.6, U2.2
unnamed: P4.4, P6.4, P8.4, U3.8
unnamed: P2.23, P4.1, P6.1, P8.1, P10.1
unnamed: P2.19, P8.10
unnamed: P2.17, P6.10
unnamed: P2.18, P6.9
unnamed: P12.1, R4.2, R6.1
unnamed: P2.24, P4.5
unnamed: P2.25, P6.5
unnamed: P2.26, P8.5
unnamed: P2.15, P4.10
unnamed: P2.16, P4.9

## KiCad design hardware/vca.kicad_pcb

Board: 2 copper layers, 83.8 x 109.2 mm, 122 parts (0 on the bottom side), 90 nets.

Parts:
C1, C2, C3, C5, C6, C7: 470n; C2
C4, C8: 22u; C1V8
C9, C10, C11, C12, C13, C14: 100u; C1V8
C15, C16: 100p; C2
C17, C18, C19, C20, C21, C22, C23, C24, C26, C29, C30, C31, C32: 100n; C2
C25: 1u; C1V8
C27, C28: 47u; C1.5V8V
HOLE1, HOLE2: P***; 1pin
IC1, IC2, IC3, IC4: LM13700; DIP-16__300_ELL
P1: VCA_CMD_PWR; SIL-9
P2: VCA_SPI; SIL-5
P3: CARD_01; SIL-2
P4: CARD_23; SIL-2
P5: CARD_45; SIL-2
P6: OUT_MAIN; SIL-4
P7: OUT_GND; SIL-3
P8: OUT_4; SIL-2
P9: OUT_2; SIL-2
P10: OUT_0; SIL-2
P11: OUT_1; SIL-2
P12: OUT_3; SIL-2
P13: OUT_5; SIL-2
R1, R2, R3, R4, R5, R6, R7, R8, R37, R38, R39, R40, R41, R42: 4k7; R1
R9, R10, R11, R12, R19, R20, R21, R22, R55, R56: 1k; R1
R13, R14, R15, R16, R17, R18: 10k; R1
R23, R24, R25, R26, R27, R28, R29, R30: 6k8; R1
R31, R32, R33, R34, R35, R36: 33k; R1
R43, R52: 33k; R3-LARGE_PADS
R44, R51: 47k; R3-LARGE_PADS
R45, R50: 150k; R3-LARGE_PADS
R46, R49: 56k; R3-LARGE_PADS
R47, R48: 68k; R3-LARGE_PADS
R53, R54: 47k; R1
R57: 100k; R1
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8: 1k; RV2X1.5
U1, U2, U3, U4: MCP4922-E/P; DIP-14__300_ELL
U5: 74HCT139; DIP-16__300_ELL
U6: TL082; DIP-8__300_ELL

Connections:
+5V: C17.1, C19.1, C21.1, C23.1, C26.1, C27.1, C29.1, C30.1, C31.1, C32.1, IC1.11, IC2.11, IC3.11, IC4.11, P1.6, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R57.1, U1.1, U1.9, U2.1, U2.9, U3.1, U3.9, U4.1, U4.9, U5.1, U5.2, U5.3, U5.16, U6.8
-5V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C18.2, C20.2, C22.2, C24.2, C28.2, IC1.6, IC2.6, IC3.6, IC4.6, P1.7, R9.2, R10.2, R11.2, R12.2, R19.2, R20.2, R21.2, R22.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, U6.4
GND: C17.2, C18.1, C19.2, C20.1, C21.2, C22.1, C23.2, C24.1, C25.2, C26.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, P1.8, P1.9, P6.2, P6.3, P7.1, P7.2, P7.3, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, RV1.2, RV2.2, RV3.2, RV4.2, RV5.2, RV6.2, RV7.2, RV8.2, U1.12, U2.12, U3.12, U4.12, U5.8, U6.3, U6.5
unnamed: IC3.13, RV5.3
unnamed: IC3.15, R27.1
unnamed: P5.2, R18.2
unnamed: P5.1, R17.2
unnamed: IC3.3, R18.1, RV6.3
unnamed: IC3.4, RV6.1
unnamed: IC3.14, R17.1, RV5.1
unnamed: IC3.2, R28.1
unnamed: C7.1, IC3.1, R6.2, R21.1
unnamed: R6.1, U3.10
unnamed: R5.1, U3.14
unnamed: C14.1, IC3.8, R42.1
unnamed: C13.1, IC3.9, R41.1
unnamed: IC3.10, IC3.12, R35.1
unnamed: IC3.5, IC3.7, R36.1
unnamed: C3.1, IC3.16, R5.2, R11.1
unnamed: C2.1, IC2.16, R3.2, R10.1
unnamed: C11.1, IC2.9, R39.1
unnamed: IC2.10, IC2.12, R33.1
unnamed: C6.1, IC2.1, R4.2, R20.1
unnamed: IC2.4, RV4.1
unnamed: IC2.2, R26.1
unnamed: IC2.13, RV3.3
unnamed: C12.1, IC2.8, R40.1
unnamed: IC2.5, IC2.7, R34.1
unnamed: P4.2, R16.2
unnamed: P4.1, R15.2
unnamed: R3.1, U2.14
unnamed: R4.1, U2.10
unnamed: U3.8, U5.10
unnamed: IC4.4, RV8.1
unnamed: IC4.2, R30.1
unnamed: U4.8, U5.9
unnamed: C16.1, IC4.5, R54.1, U6.6
unnamed: C15.1, IC4.12, R53.1, U6.2
unnamed: C9.2, P10.2
unnamed: C12.2, P12.2
unnamed: C11.2, P9.2
unnamed: C10.2, P11.2
unnamed: U2.8, U5.11
unnamed: U1.8, U5.12
unnamed: C14.2, P13.2
unnamed: C13.2, P8.2
unnamed: P1.3, U5.14
unnamed: P1.5, U5.15
unnamed: P1.2, U5.13
unnamed: C4.1, IC4.16, R7.2, R12.1
unnamed: IC4.15, R29.1
unnamed: IC4.13, RV7.3
unnamed: R7.1, U4.14
unnamed: R8.1, U4.10
unnamed: C8.1, IC4.1, R8.2, R22.1
unnamed: C15.2, R53.2, R56.2, U6.1
unnamed: IC4.3, R45.2, R47.2, R49.2, R51.2, R52.2, RV8.3
unnamed: C16.2, R54.2, R55.2, U6.7
unnamed: P8.1, R43.1
unnamed: P13.1, R52.1
unnamed: IC1.4, RV2.1
unnamed: IC1.2, R24.1
unnamed: C5.1, IC1.1, R2.2, R19.1
unnamed: P11.1, R48.1, R49.1
unnamed: P9.1, R44.1, R45.1
unnamed: P10.1, R46.1, R47.1
unnamed: P12.1, R50.1, R51.1
unnamed: P6.1, R55.1
unnamed: P6.4, R56.1
unnamed: IC4.14, R43.2, R44.2, R46.2, R48.2, R50.2, RV7.1
unnamed: R2.1, U1.10
unnamed: R1.1, U1.14
unnamed: P2.3, U1.3, U2.3, U3.3, U4.3
unnamed: P2.2, U1.4, U2.4, U3.4, U4.4
unnamed: P2.1, U1.5, U2.5, U3.5, U4.5
unnamed: IC1.14, R13.1, RV1.1
unnamed: IC1.13, RV1.3
unnamed: IC2.15, R25.1
unnamed: P3.2, R14.2
unnamed: P3.1, R13.2
unnamed: IC2.3, R16.1, RV4.3
unnamed: IC2.14, R15.1, RV3.1
unnamed: IC1.15, R23.1
unnamed: C10.1, IC1.8, R38.1
unnamed: C9.1, IC1.9, R37.1
unnamed: C1.1, IC1.16, R1.2, R9.1
unnamed: IC1.10, IC1.12, R31.1
unnamed: IC1.3, R14.1, RV2.3
unnamed: IC1.5, IC1.7, R32.1
VAA: C25.1, R57.2, U1.11, U1.13, U2.11, U2.13, U3.11, U3.13, U4.11, U4.13

## KiCad design hardware/voice.kicad_pcb

Board: 2 copper layers, 99.1 x 50.8 mm, 56 parts (0 on the bottom side), 61 nets.

Parts:
C1, C2, C3, C4, C21, C22: 10u; C1V5
C5, C6, C8, C9, C10, C12, C25, C26, C27, C28, C29: 100n; C2
C7, C11: 47n; C2
C13, C15: 820p; C2
C14, C16, C17, C18, C19, C20: 10n; C2
C23, C24: 47u; C2V8
K1: PWR; SIL-3
P1: DATA; SIL-10
P2: OUT; SIL-2
R1, R2, R3, R4: 15k; R3-LARGE_PADS
R5, R6: 220; R1
R7, R8: 4k7; R1
R9, R10: 6k8; R1
R11, R13: 220; R3-LARGE_PADS
R12, R14: 470; R3-LARGE_PADS
R15, R16: 8k2; R3-LARGE_PADS
R17, R18: 18k; R3-LARGE_PADS
U1: 4051; DIP-16__300_ELL
U2, U3: MCP4922-E/P; DIP-14__300_ELL
U4: TL074; DIP-14__300_ELL
U5, U6: SSM2044; DIP-16__300_ELL

Connections:
+5V: C23.1, C25.1, C27.1, C28.1, K1.1, U1.16, U2.1, U2.9, U3.1, U3.9, U4.4, U5.16, U6.16
-5V: C24.2, C26.2, C29.2, K1.3, R17.1, R18.1, U1.7, U4.11, U5.9, U6.9
//CS: P1.6, U2.3, U3.3
//LDAC_A: P1.10, U2.8
//LDAC_B: P1.9, U3.8
/OUT_A: C21.2, P2.1
/OUT_B: C22.2, P2.2
/SCK: P1.7, U2.4, U3.4
/SDI: P1.8, U2.5, U3.5
GND: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C23.2, C24.1, C25.2, C26.1, C27.2, C28.2, C29.1, K1.2, R5.1, R6.1, R11.1, R12.1, R13.1, R14.1, R15.2, R16.2, U1.8, U2.12, U3.12, U5.8, U6.8
unnamed: R11.2, U5.15
unnamed: C13.1, U5.4
unnamed: C1.1, U2.14
unnamed: C2.1, U2.10
unnamed: C19.1, U6.12
unnamed: C20.2, U6.11
unnamed: C20.1, U6.10
unnamed: C19.2, U6.14
unnamed: R13.2, U6.15
unnamed: C15.1, U6.4
unnamed: R7.2, U5.2
unnamed: C16.1, U6.6
unnamed: C15.2, U6.5
unnamed: C16.2, U6.7
unnamed: R8.1, U4.13, U4.14
unnamed: R9.1, U4.8, U4.9
unnamed: C3.1, U3.14
unnamed: C4.1, U3.10
unnamed: C4.2, R4.1
unnamed: C3.2, R3.1
unnamed: C1.2, R1.1
unnamed: C2.2, R2.1
unnamed: C17.2, U5.14
unnamed: C13.2, U5.5
unnamed: C14.1, U5.6
unnamed: C14.2, U5.7
unnamed: C17.1, U5.12
unnamed: C18.2, U5.11
unnamed: C18.1, U5.10
unnamed: R1.2, R2.2, R5.2, U5.1
unnamed: P1.4, U1.3
unnamed: C22.1, R16.1, U6.3
unnamed: C21.1, R15.1, U5.3
unnamed: P1.1, U1.9
unnamed: P1.5, U1.6
unnamed: P1.2, U1.10
unnamed: R8.2, U6.2
unnamed: R10.1, U4.1, U4.2
unnamed: R3.2, R4.2, R6.2, U6.1
unnamed: R9.2, R12.2, R17.2, U5.13
unnamed: R7.1, U4.6, U4.7
unnamed: P1.3, U1.11
unnamed: R10.2, R14.2, R18.2, U6.13
unnamed: C10.1, U1.5, U3.11
unnamed: C9.1, U1.1, U3.13
unnamed: C11.1, U1.2, U4.3
unnamed: C12.1, U1.4, U4.12
unnamed: C8.1, U1.12, U4.5
unnamed: C5.1, U1.13, U2.13
unnamed: C6.1, U1.14, U2.11
unnamed: C7.1, U1.15, U4.10

## Commit log (part)

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2021-12-03 fixed blog url
2022-01-20 wtosc: removed guard band (back to original gain staging)
2022-01-20 hw: fixed voice tuning note
2022-01-20 synchronous CV updates @ 2500Hz (adsr & lfo speed div) -- sanitized scan llis synth @ 80Khz now, system timer @500hz for slow stuff
2022-01-24 uart_midi: init/ack clarification
2022-01-31 new string-based way of storing wtoscs waveforms choices -- "preset modified" UI info
2022-05-07 midi: arp transposed fix
2023-02-02 crossover bugfixes (copy b to xovr; oob in assigner_getLatestAssigned)
2023-09-29 ui: fullscreen mode displays value list
2023-09-30 ui: XoCp from oscillator A
2023-10-01 loopable envelopes -- lin/exp for amplifier envelope
2023-10-03 ui/scan: pots values now need to be reacquired when changing page
2023-10-06 wtosc: improved oscOctaveCurve -- simplified wtosc_setParameters
2023-10-06 doc: adding utility spreadsheets
2023-10-07 wtosc: simplified frequency computation
2023-10-08 New toolchain ( arm-gnu-toolchain-12.3.rel1-mingw-w64-i686-arm-none-eabi.exe )
2023-10-08 wtosc: sync bugfix -- syncResets simplification
2023-10-09 wtosc: reverted half phase changes (problems with aliasing cv)
2023-10-09 ui: fixed disrepancy between settings.presetNumber and ui state
2023-10-12 Migrated Overcycler2 hardware to KiCad 7.08
2023-10-14 hardware: OverCycler3 schematics WIP2
2023-10-16 hardware: SSM2044 -> SSI2144
2023-10-16 hardware: noise transistor change -- minor fixes
2023-10-17 hardware: adjusted mixer levels
2023-10-19 hardware: overcycler2 -> overcycler3 rename
2023-10-20 hardware: draft PCB placement
2023-10-24 hardware: improved draft routing
2023-10-25 hardware: silkscreen improvements
2023-10-29 hardware: improved routing
2023-11-03 more oscs / wmod separation -- proper OscA and OscB freq
2023-11-07 Revert "wtosc: incModLUT opti" (fixes ProphetVS waves wixed with AKWF)
2023-11-19 Manual PCB routing by Guimli WIP2
2023-11-28 Manual PCB routing by Guimli Done!
2023-12-17 ui: reworked patch load pots in hundreds/tens/units -- ui: refact
2023-12-21 midi: fix loading empty patch from prog change
2023-12-26 ui: numerically set potentiometer value / preset number -- refact
2023-12-28 hardware: proper production files for JLCPCB
2023-12-29 hardware: proper production files for JLCPCB (oops! diodes were reversed)
2024-01-11 wtosc: 2 sided aliasing, ring-mod like in negative, grith in positive
2024-01-11 storage: cleaner preset_loadDefault bank/wave management, LFO2 unused by default now
2024-01-11 midi: proper MIDI_NOTE_TRANSPOSE_OFFSET use/value
2024-01-12 synth: base filter tracking note changed to C4 -- cleanup
2024-01-12 ui: improved screen delimiter ("preset modified", visual envelopes) -- refact
2024-01-20 utils: buffer_dump rprintf fix
2024-01-21 doc: adding missing datasheet, cleanup
2024-01-22 nand: unit test
2024-01-23 scan: working pots scan using TLV2556 ADC
2024-01-23 synth: cleanup
2024-01-24 nand: now emulating 4096 bytes sectors (faster)
2024-01-25 usb: using interrupts instead of polling
2024-01-25 xt26g: recover from and propagate errors to the upper layer -- nand: handle XT26G errors, write speedup
2024-01-26 usb: Adding usb_power, misc fixes -- ui: adding USB Mode setting
2024-01-26 ui: cosmetics
2024-01-27 scan: scan all pots at once (regardless of previous scan)
2024-01-27 ui: moved "Sync" to Seq/Arp page
2024-01-27 ui: uiCustomParamNumber_e replacing manually numbered custom params
2024-01-28 system: 120Mhz peripheral clock
2024-01-28 main: less debug
2024-01-28 dacspi: cleanup, tweaks
2024-01-28 ui: bugfixes
2024-01-29 ui: LCD contrast extents
2024-01-29 synth: refact
2024-01-29 tuner: working!
2024-01-29 ui: silence synth on preset load
2024-01-30 dacspi: better init order
2024-01-30 tuner: fixed point math, cleanup
2024-01-30 tuner: improved measureAudioPeriod (init fix, dual sided)
2024-01-30 ui: USB bugfix, intro screen button names
2024-01-31 spice: vcnoise update from sch
2024-01-31 usb: no more need to restart to change USB mode (pulling D+ and D- low to disconnect)
2024-02-01 assigner: rework for proper stolen voices restoration in poly mode
2024-02-01 midi: channel pressure implementation
2024-02-02 synth: modOff -> modNone
2024-02-02 synth: refreshEnvSettings refact -- ui: cleanup
2024-02-02 dacspi: reset on init, CV DACs init, tweaks
2024-02-03 midi: some more "free" midi CCs (trous propres :D)
2024-02-03 synth: crossover on both oscillators :) -- refact
2024-02-03 storage: bugfix, half volume by default
2024-02-03 doc: typo
2024-02-03 midi: deferred disk accesses -- synth: bugfix
2024-02-04 storage: migrated dual sided crossover
2024-02-04 storage: this must be done even in not makeSound to ensure bw compatibility
2024-02-05 Adding a bootloader to be able to do in-application programming
2024-02-05 boot: leaner! (using sprintf() takes 40KB!), cleanup
2024-02-06 dacspi: better use of channel wait states, allowing 20MHz SPI
2024-02-06 tuner: algo improvements and tweaks
2024-02-07 hardware: oc3 hardware R2 (ferrite on the ADC reference)
2024-02-08 scan: bugfix, reverted to an older version of the locking algo to prevend spurious locks
2024-02-08 scan: LLI bugfixes, cleanup
2024-02-08 tuner: lli pot offset after tune bugfix
2024-02-09 wtosc: reactivate guard band (preventing aliasing from clipping)
2024-02-09 dacspi: taylored wait states to number of SSP writes
2024-02-10 tuner: fixed out of tuning spurious ui changes, refact -- scan: scan_setMode to enclose scan_sampleMasterMix calls -- ui: fix timeouts init
2024-02-10 cleanup
2024-02-11 dacspi: whoops, low DACSPI_TIMER_MATCH don't work at proper sample rate -- wtosc: WIDTH_MOD_BITS=10, refact -- synth: synth_timerEvent on 10 phases
2024-02-11 scan: out of lock -> current value must be taken into account
2024-02-12 synth: cutoff tuned in C
2024-02-12 hardware: missing fillets
2024-02-14 clock: refactoring for better encapsulation, internal clock is now in BPM -- refact
2024-02-14 system: slightly faster flash accesses, disabled clk out
2024-02-14 ui: renaming
2024-02-15 rprintf: implemented srprintf -- overall ~20KB reduction in firmware size by not using stdio
2024-02-15 ui: fix locked unattainable value, refact, comments
2024-02-16 synth: fix disparate sampleCount for A/AXo and B/BXo
2024-02-16 storage: default patch tweaks
2024-02-17 storage: steppedParametersSteps fix
2024-02-18 ui: transpose displayed in note names, bugfixes, refact
2024-02-18 storage: LFO speed migration to BPM
2024-02-19 synth: fixed loading 8.3 bank and wave names, default waveform _basic/saw.wav
2024-02-19 hardware: adding filters on MIXA/MIXB/MIXN CVs -- needs PCB update
2024-02-20 ui: USB mode now none->disk->midi, so that midi mode is kept after MSC session
2024-02-21 ui: fix "set digits" for custom param
2024-02-21 vca_curves: improved curve -- vcnoise_curves: tidying
2024-02-23 dacspi: CVs double buffer -- synth: all CV updates moved to synth_updateCVsEvent
2024-02-23 hardware: adjusted mixer output level (cf. prev commit), USB ground now entirely disconnected from GND
2024-02-24 synth: adjustCV cvAmp output level limit ot 5vPP
2024-02-25 dacspi: 64 buffers, DMA_IRQHandler doing CV/Osc updated twice to compensate -- refact
2024-02-25 synth: slightly boosted pre-filter mixer levels analog, baby :D
2024-02-26 ui: "preset exists" warning on save, display preset number on prev/next, tweaks
2024-02-26 synth: added LFO1/2 Speed multiplier, ui+storage changes -- ui: moved 1Tgt/2Tgt back to buttons
2024-02-28 hardware: TL074->TL064 (with datasheet), remade ADC reference (with spice sim)
2024-02-28 ui: help message on the presets page
2024-03-28 resample all waveforms to 2400 samples on load
2024-04-01 wtosc: tweaks
2024-04-03 synth: silence voice DACs when vol A/B is zero
2024-04-20 hardware: sch update (AD5674R replacing AD5328B*2)
2024-04-28 hardware: sch/pcb updates by Guimli
2024-05-07 hardware: pcb updates by Guimli
2024-05-11 enclosure: fixed Rear
2024-06-04 ui: ported LCD to new board rev -- hd44780: fixed waits (improve compatibility with LCDs)
2024-06-04 fat_nand -> fat (NOR flash)
2024-06-06 usb: fix buffer overflow preventing USB from working -- some more ERR_INT error handling in isr
2024-06-13 tuner: fix low octave not tuning
2024-06-16 synth: fix modwheel/pressure volume to noise CV
2024-06-16 ui: tweaked min contrast to be barely readable
2024-06-16 hardware: voice mixer -> 820 ohms
2024-06-16 hwarware: IA0505S-2W, JETEKPS -> RLT
2024-06-16 synth: avoid output saturation by limiting the max VCA level
2024-06-16 disk: adding unreworked factory patches
2024-06-17 scan: fload based to/from 16bits pot conversion (fixes disrepancies when saving/loading patch)
2024-06-17 tuner: rework
2024-06-19 ui: startup page now a proper page (fixes tranposing for this page)
2024-06-19 Add ADuM3160 and correct enclosure rear
    - ADuM3160 added for USB isolation
    - Correction of USB traces to respect 90Ω in two-layer PCBs
    - Integration of Noise circuit modifications
2024-06-22 sch: making the volume pot antilog by adding a wiper resistor
2024-06-23 ui: proper in and out of tuner
2024-06-23 usb: USBHwPreinit at boot time
2024-06-24 Add USB pullup resistor
    - Add USB pullup resistor
2024-06-24 boot: fix contrast multiplier
2024-06-26 dacspi: cleanup
2024-06-26 lfo: hardcode sine table to reduce RAM usage
2024-06-26 hardware: updated some LCSC references
2024-06-29 dacspi: simplified cvCommands LLI build
2024-06-29 dacspi: only one timer tick to push 2 values thru SPI
2024-07-02 dacspi: small opti -- synth: VCA CV now full swing -- tuner: fixes
2024-07-03 scan: rework for one-shot pots scanning
2024-07-04 Revert "scan: rework for one-shot pots scanning" Because this caused sound glitches
2024-07-04 disk: presets refinements
2024-07-04 synth: half scale to avoid VCA clipping
2024-07-06 synth: half scale for AWmo/BWmo to freq mod
2024-07-07 hardware: adding C133 power cap for U17
2024-07-07 hardware: 47uF reservoir for 3V3 (properer than prev commit)
2024-07-08 hardware: updated PCB and production files (47uF reservoir for 3V3)
2024-07-10 wtosc: opti (unrolled for sync)
2024-07-10 scan: don't call eventCallback twice
2024-07-18 synth: take settings.voiceMask into account (refreshAssignerSettings)
2024-08-10 Addition of a PCB for potentiometer connection
    - Addition of a PCB for potentiometer connection
    - Addition of a missing track on U19
    - Overhaul of component rotation in JLCPCB plugin
2024-08-13 hardware: BC858B -> BC856B
2024-08-25 manual: "basic ergonomics" section
2024-09-04 manual: pages 1/2/3/4 draft
2024-09-05 disk: adding PDF render of the manual
2024-09-08 manual: draft version done!
2024-09-11 manual: removed some quirks and closed comments
2024-09-30 wtosc: speedup
2024-10-05 synth: "VCA level" feature
2024-10-07 ui: don't display file name extension in drawWaveform
2024-10-11 wtosc: major rewrite, unrolled for only one wavemod at a time (speedup!) -- crossover bugfix
2024-10-13 wtosc: crossover extents bugfix
2024-10-14 assigner: clarification
2024-10-15 lfo: keyboard trigger feature
2024-10-17 ui: faster/preciser drawWaveform -- SLOW_UPDATE_TIMEOUT = 0.5s -- scan: scan_sampleMasterMix improved normalization
2024-10-17 ui: "Quitting USB Disk mode..." text
2024-10-17 rename cpVCALevel -> cpAmpLevel (for coherency)
2024-10-18 disk: updated "factory" presets names and volume levels
2024-10-22 lfo: improved phase for lsSaw and lsRevSaw
2024-10-25 wtosc: reverted buggy optimisation (fixes aliasing on highest notes)
2024-10-25 wtosc: constified incModLUT (RAM opti, slightly faster)
2024-10-25 Revert "wtosc: reverted buggy optimisation (fixes aliasing on highest notes)" -- Optimisation made proper (still slightly faster)
    This reverts commit 1c1a69aa995f36cdd01cb4f7e6ac3b96cb7aee70.
2024-10-25 ui_pages: oops! (cnTrspV indicating the wrong key)
2024-10-26 ui: allow more than 8 values per parameter, cleanup, tidying -- storage: adding "Perc" and "FX" for spPresetType
2024-10-26 ui: bugfixes from prev commit
2024-10-28 harware: changed some LCSC refs to accomodate for stock
2024-10-29 ui: basic preset should have no number
2024-10-29 synth: synth_silenceSynth, replaces silencing the voices by hand
2024-10-29 wtosc: WTOSC_HIGHEST_NOTE = 108; no interpolation reduction if no grit; max duty cycle is now dependant on pitch overall try to reduce bugs or limit aliasing on highest notes
